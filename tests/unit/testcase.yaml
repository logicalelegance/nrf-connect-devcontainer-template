## tests/unit/testcase.yaml
```yaml
tests:
  blink.logic:
    platform_allow:
      - native_sim/native/64
    tags: unit
```
